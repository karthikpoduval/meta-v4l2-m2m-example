FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-libcamera-export-internal-headers-for-m2m-devices.patch"

