KERNEL_FEATURES:append:qemuall ="\
	features/media/media-platform.scc \
"
